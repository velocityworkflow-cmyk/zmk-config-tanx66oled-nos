## boards/shields/tanx66oled-nos/Kconfig.shield
```kconfig
config SHIELD_TANX66OLED_NOS
    def_bool $(shields_list_contains,tanx66oled-nos)
```
